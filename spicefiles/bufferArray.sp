**********************************
**** INVERTER: simple example
**********************************

* Simulation setup
*------------------
*Some simulation options
.options post nomod
.option opts fast parhier=local

*Add the 45nm CMOS library. Notice how the path is generated by MATLAB
.lib '/users/start2012/r0305883/Master2/DDIS/DDIS1/Resources/Technology/tech_wrapper.lib ' tt

*Add the .vec file
.vec '/users/start2012/r0305883/Master2/DDIS/DDIS1/m2sfiles/bufferArray.vec'

.tran 0.001n 5n *Do a transient simulation, final time = 5ns
.probe v i

.param supply = 1

* Voltage sources
*-----------------
Vdd vdd vss supply
Vss vss 0 0

* Simulated circuit
*-------------------

    Xnota0 in0 inb0 vdd vss MYNOT
    Xnotb0 inb0 out0 vdd vss MYNOT
    Cap0 out0 vss 10f
    Xnota1 in1 inb1 vdd vss MYNOT
    Xnotb1 inb1 out1 vdd vss MYNOT
    Cap1 out1 vss 10f
    Xnota2 in2 inb2 vdd vss MYNOT
    Xnotb2 inb2 out2 vdd vss MYNOT
    Cap2 out2 vss 10f
    Xnota3 in3 inb3 vdd vss MYNOT
    Xnotb3 inb3 out3 vdd vss MYNOT
    Cap3 out3 vss 10f
    Xnota4 in4 inb4 vdd vss MYNOT
    Xnotb4 inb4 out4 vdd vss MYNOT
    Cap4 out4 vss 10f
    Xnota5 in5 inb5 vdd vss MYNOT
    Xnotb5 inb5 out5 vdd vss MYNOT
    Cap5 out5 vss 10f
    Xnota6 in6 inb6 vdd vss MYNOT
    Xnotb6 inb6 out6 vdd vss MYNOT
    Cap6 out6 vss 10f
    Xnota7 in7 inb7 vdd vss MYNOT
    Xnotb7 inb7 out7 vdd vss MYNOT
    Cap7 out7 vss 10f
    Xnota8 in8 inb8 vdd vss MYNOT
    Xnotb8 inb8 out8 vdd vss MYNOT
    Cap8 out8 vss 10f
    Xnota9 in9 inb9 vdd vss MYNOT
    Xnotb9 inb9 out9 vdd vss MYNOT
    Cap9 out9 vss 10f
    Xnota10 in10 inb10 vdd vss MYNOT
    Xnotb10 inb10 out10 vdd vss MYNOT
    Cap10 out10 vss 10f
    Xnota11 in11 inb11 vdd vss MYNOT
    Xnotb11 inb11 out11 vdd vss MYNOT
    Cap11 out11 vss 10f
    Xnota12 in12 inb12 vdd vss MYNOT
    Xnotb12 inb12 out12 vdd vss MYNOT
    Cap12 out12 vss 10f
    Xnota13 in13 inb13 vdd vss MYNOT
    Xnotb13 inb13 out13 vdd vss MYNOT
    Cap13 out13 vss 10f
    Xnota14 in14 inb14 vdd vss MYNOT
    Xnotb14 inb14 out14 vdd vss MYNOT
    Cap14 out14 vss 10f
    Xnota15 in15 inb15 vdd vss MYNOT
    Xnotb15 inb15 out15 vdd vss MYNOT
    Cap15 out15 vss 10f

* Subcircuits
*-------------
.SUBCKT MYNOT input output vdd vss multfac='1'
xM1 output input vss vss MOSN w='multfac*120e-9' l='45e-9'
xM2 output input vdd vdd MOSP w='multfac*2*120e-9' l='45e-9'
.ENDS MYNOT

.END
